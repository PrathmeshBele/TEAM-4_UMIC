Commit message: Bot11

File: Mechanical/bot11/urdf/bot11.urdf (robot description, URDF)
Before this commit: robot bot11, 15 links, 14 joints
Links:
- removed link F1
Joints:
- removed joint F1J
- joint BJ: axis 0 0 -1 -> 0 -1 0
